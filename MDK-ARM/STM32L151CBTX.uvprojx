# Keil uVision project STM32L151CBTX.uvprojx, settings and files
target STM32L151CBTX (5060528::V5.06 update 5 (build 528)::ARMCC)
  device: STM32L151CB STMicroelectronics
  pack: Keil.STM32L1xx_DFP.1.2.0
  cpu: IRAM(0x20000000-0x20003FFF) IROM(0x8000000-0x801FFFF) CLOCK(8000000) CPUTYPE("Cortex-M3")
  output: STM32L151CBTX +hex
  AfterMake: c:\Keil_v5\ARM\ARMCC\bin\fromelf.exe --bin -o .\object\STM32L151CBTX.bin .\STM32L151CBTX\STM32L151CBTX.axf
  c flags: Optim=4 OneElfS=1 v6Lang=1 v6LangP=1 wLevel=2
  c define: USE_HAL_DRIVER,STM32L151xB
  c misc: --C99
  c include: ../Inc;    ../Drivers/STM32L1xx_HAL_Driver/Inc;    ../Drivers/STM32L1xx_HAL_Driver/Inc/Legacy;    ../Drivers/CMSIS/Device/ST/STM32L1xx/Include;    ../Drivers/CMSIS/Include;    ../Src/radio;    ../Src/meter
  library: MicroLIB
  memory RVCT4: ROM 0x8000000 size 0x20000
  memory RVCT9: RAM 0x20000000 size 0x4000
  link misc: --diag_suppress=L6329
  group Drivers/CMSIS
    ../Src/: system_stm32l1xx.c
  group Application/User
    ../Src/: gpio.c usart.c stm32l1xx_hal_msp.c rtc.c stm32l1xx_lp_modes.c main.c spi.c dma.c stm32l1xx_it.c
  group Drivers/STM32L1xx_HAL_Driver
    ../Drivers/STM32L1xx_HAL_Driver/Src/: stm32l1xx_hal_rcc.c stm32l1xx_hal_flash_ramfunc.c stm32l1xx_hal_tim_ex.c stm32l1xx_hal_spi.c stm32l1xx_hal_cortex.c stm32l1xx_hal_uart.c stm32l1xx_hal_pwr_ex.c stm32l1xx_hal_pwr.c stm32l1xx_hal_rcc_ex.c stm32l1xx_hal_dma.c stm32l1xx_hal_rtc.c stm32l1xx_hal_rtc_ex.c stm32l1xx_hal_spi_ex.c stm32l1xx_hal_gpio.c stm32l1xx_hal_tim.c stm32l1xx_hal.c stm32l1xx_hal_flash_ex.c stm32l1xx_hal_flash.c
  group Application/MDK-ARM
    ./: startup_stm32l151xb.s
  group radio
    ../Src/radio/: sx1276.c sx1276-Hal.c sx1276-LoRa.c sx1276-LoRaMisc.c
  group meter
    ../Src/meter/: dlt645.c cj188.c
software components: CMSIS:CORE 4.1.0
